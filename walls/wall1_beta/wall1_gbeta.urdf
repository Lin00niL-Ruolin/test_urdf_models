Commit message: 基座显性定义

File: walls/wall1_beta/wall1_gbeta.urdf (robot description, URDF)
Before this commit: robot wall1_beta, 1 links, 1 joints
Links:
- added link world, mass 0
- link baseLink: mass 0.0 -> 500.0
